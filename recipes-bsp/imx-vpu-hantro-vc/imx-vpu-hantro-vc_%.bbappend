COMPATIBLE_MACHINE = "(imx8mp-iwg40m|imx8mp-iwg40m-2gb)"
